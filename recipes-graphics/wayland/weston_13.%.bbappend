SRC_URI:remove:zynqmp = " file://0001-libweston-Remove-substitute-format-for-ARGB8888.patch "

